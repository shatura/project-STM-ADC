# IAR project FreeRTOS_REG.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051R8 ST STM32F051R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F051
  ICCARM.CCIncludePath2: ..\Inc; ..\Core_Inc; ..\ST_Inc; ..\FreeRTOS\Source\include; ..\FreeRTOS\Source\CMSIS_RTOS; ..\FreeRTOS\Source\portable\IAR\ARM_CM0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32f051x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group FreeRTOS
    ../FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c
  group System
    ../FreeRTOS/Source/portable/IAR/ARM_CM0/: portasm.s
    ../Src/: startup_stm32f0xx.s
  group USER
    ../Src/: Generator.c main.c Measurements.c PWM_Tim1.c sqrt_GLS.c stm32f0xx_it.c System_HSE_init.c UART.c
